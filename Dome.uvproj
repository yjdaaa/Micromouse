# Keil uVision project Dome.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Dome
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: .\Source\HARDWARE;.\Source\SYSTEM\delay;.\Source\SYSTEM\sys;.\Source\SYSTEM\usart;.\Source\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./Source/USER/: maze.c Mouse_Drive.c
  group SYSTEM
    ./Source/SYSTEM/delay/: delay.c
    ./Source/SYSTEM/sys/: sys.c
    ./Source/SYSTEM/usart/: usart.c
  group HARDWARE
    ./Source/HARDWARE/: adc.c Encoder.c iic.c key.c led.c pwm.c stmflash.c timer.c Zlg7289.c zp_GPIO.c zp_usart.c
